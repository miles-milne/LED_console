File: kicad/led_2048/led_2048.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: minor schematic revisions
Other:
- sheet Press buttons renamed Push buttons
